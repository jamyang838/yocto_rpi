#SRC_URI_prepend_1.0.0 = "git://github.com/WiringPi/WiringPi.git  \"
PREMIRRORS = "\
 git://.*/.*   git://github.com/WiringPi/WiringPi.git \n \
"